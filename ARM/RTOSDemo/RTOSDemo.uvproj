# Keil uVision project RTOSDemo.uvproj, settings and files
target AutoRover (ARM-GNU)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: AutoRover
  group FreeRTOS
    ../FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/GCC/ARM_CM3/: port.c
  group MainSource
    ./MainFiles/: main.c myTimers.c taskConductor.c taskLCD.c taskSensors.c
    ../vtCode/: vtUtilities.c
    ../FreeRTOS/Demo/CORTEX_LPC1768_GCC_Rowley/: ParTest.c
  group System Files
    ../SystemFiles/: syscalls.c system_LPC17xx.c startup_LPC17xx.s
  group LPCUSB
    ../LPCUSB/: USB_CDC.c
    ../FreeRTOS/Demo/CORTEX_LPC1768_GCC_Rowley/LPCUSB/: usbcontrol.c usbhw_lpc.c usbinit.c usbstdreq.c
  group LCD
    ../vtCode/vtLCD/: vtSSP.c GLCD_SPI_LPC1700.c
  group Drivers
    ../NXPDrivers/source/: lpc17xx_clkpwr.c lpc17xx_i2c.c lpc17xx_libcfg_default.c lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_ssp.c
  group I2C
    ../vtCode/vtI2C/: vtI2C.c
